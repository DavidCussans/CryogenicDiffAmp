.title KiCad schematic
.include "Infineon-RFTransistor-SPICE.lib-SM-v02_10-EN.lib"
.include "SiPMT_model2.cir"
V5 Net-_D1-Pad3_ 0 dc 0 ac 0 pulse(0V 1V 50n 1n 1n 1n)
R21 /differentialAmplifierCSA/vout- /vin+ 100k
C5 /differentialAmplifierCSA/vout- /vin+ 160p
R20 /differentialAmplifierCSA/vout+ /vin- 100k
C4 /differentialAmplifierCSA/vout+ /vin- 160p
R18 /vin- VEE 130k
R19 /vin+ VEE 130k
V1 VCC 0 dc 7
V2 0 VEE dc 7
R27 /vout- /differentialAmplifierBuffer/Vin+ 10k
C9 /vout- /differentialAmplifierBuffer/Vin+ 160p
R26 /vout+ /differentialAmplifierBuffer/Vin- 10k
C8 /vout+ /differentialAmplifierBuffer/Vin- 160p
R22 /differentialAmplifierBuffer/Vin- VEE 13k
R23 /differentialAmplifierBuffer/Vin+ VEE 13k
R24 /differentialAmplifierBuffer/Vin- Net-_C6-Pad1_ 10k
R25 /differentialAmplifierBuffer/Vin+ Net-_C7-Pad1_ 10k
C6 Net-_C6-Pad1_ /differentialAmplifierCSA/vout+ 160p
C7 Net-_C7-Pad1_ /differentialAmplifierCSA/vout- 160p
XD1 /va /vk Net-_D1-Pad3_ SiPMT
R45 /vk Net-_R45-Pad2_ 100k
R46 /va 0 100k
C13 /vin- /vk 47n
C14 /vin+ /va 47n
V3 Net-_R45-Pad2_ 0 72.0
XU5 Net-_R13-Pad2_ /differentialAmplifierCSA/Vb2 /differentialAmplifierCSA/ve /differentialAmplifierCSA/ve BFP650
XU4 /differentialAmplifierCSA/vcc2 /differentialAmplifierCSA/vcb2 /differentialAmplifierCSA/vce2 /differentialAmplifierCSA/vce2 BFP650
XU2 /differentialAmplifierCSA/vcc1 /differentialAmplifierCSA/vcb1 /differentialAmplifierCSA/vce1 /differentialAmplifierCSA/vce1 BFP650
XU3 Net-_R5-Pad2_ /differentialAmplifierCSA/Vb1 /differentialAmplifierCSA/ve /differentialAmplifierCSA/ve BFP650
R4 VCC /differentialAmplifierCSA/vcc1 1K
R12 VCC /differentialAmplifierCSA/vcc2 1K
R9 /differentialAmplifierCSA/ve VEE 1k
R7 /vin- /differentialAmplifierCSA/Vb1 10
R11 /differentialAmplifierCSA/Vb2 /vin+ 10
R13 /differentialAmplifierCSA/vce2 Net-_R13-Pad2_ 10
R5 /differentialAmplifierCSA/vce1 Net-_R5-Pad2_ 10
R10 /differentialAmplifierCSA/vcb2 /differentialAmplifierCSA/vcb 20
R8 /differentialAmplifierCSA/vcb /differentialAmplifierCSA/vcb1 20
C2 VCC /differentialAmplifierCSA/vcc2 15p
C1 VCC /differentialAmplifierCSA/vcc1 15p
XU6 /differentialAmplifierCSA/vcoutp /differentialAmplifierCSA/vbuf2 /differentialAmplifierCSA/vout- /differentialAmplifierCSA/vout- BFP650
XU1 /differentialAmplifierCSA/vcoutm /differentialAmplifierCSA/vbuf1 /differentialAmplifierCSA/vout+ /differentialAmplifierCSA/vout+ BFP650
R16 VCC /differentialAmplifierCSA/vcoutp 1K
R1 VCC /differentialAmplifierCSA/vcoutm 1K
R3 /differentialAmplifierCSA/vcc1 /differentialAmplifierCSA/vbuf1 10
R15 /differentialAmplifierCSA/vbuf2 /differentialAmplifierCSA/vcc2 10
R17 /differentialAmplifierCSA/vout- VEE 4k
R2 /differentialAmplifierCSA/vout+ VEE 4k
R6 VCC /differentialAmplifierCSA/vcb 10k
R14 /differentialAmplifierCSA/vcb VEE 18k
C3 /differentialAmplifierCSA/vcb 0 C
XU11 Net-_R39-Pad2_ /differentialAmplifierBuffer/Vb2 /differentialAmplifierBuffer/ve /differentialAmplifierBuffer/ve BFP650
XU10 /differentialAmplifierBuffer/vcc2 /differentialAmplifierBuffer/vcb2 /differentialAmplifierBuffer/vce2 /differentialAmplifierBuffer/vce2 BFP650
XU8 /differentialAmplifierBuffer/vcc1 /differentialAmplifierBuffer/vcb1 /differentialAmplifierBuffer/vce1 /differentialAmplifierBuffer/vce1 BFP650
XU9 Net-_R32-Pad2_ /differentialAmplifierBuffer/Vb1 /differentialAmplifierBuffer/ve /differentialAmplifierBuffer/ve BFP650
R31 VCC /differentialAmplifierBuffer/vcc1 1K
R38 VCC /differentialAmplifierBuffer/vcc2 1K
R35 /differentialAmplifierBuffer/ve VEE 1k
R33 /differentialAmplifierBuffer/Vin- /differentialAmplifierBuffer/Vb1 10
R37 /differentialAmplifierBuffer/Vb2 /differentialAmplifierBuffer/Vin+ 10
R39 /differentialAmplifierBuffer/vce2 Net-_R39-Pad2_ 10
R32 /differentialAmplifierBuffer/vce1 Net-_R32-Pad2_ 10
R36 /differentialAmplifierBuffer/vcb2 /differentialAmplifierBuffer/vcb 20
R34 /differentialAmplifierBuffer/vcb /differentialAmplifierBuffer/vcb1 20
C11 VCC /differentialAmplifierBuffer/vcc2 15p
C10 VCC /differentialAmplifierBuffer/vcc1 15p
XU12 /differentialAmplifierBuffer/vcoutp /differentialAmplifierBuffer/vbuf2 /vout- /vout- BFP650
XU7 /differentialAmplifierBuffer/vcoutm /differentialAmplifierBuffer/vbuf1 /vout+ /vout+ BFP650
R41 VCC /differentialAmplifierBuffer/vcoutp 1K
R28 VCC /differentialAmplifierBuffer/vcoutm 1K
R30 /differentialAmplifierBuffer/vcc1 /differentialAmplifierBuffer/vbuf1 10
R40 /differentialAmplifierBuffer/vbuf2 /differentialAmplifierBuffer/vcc2 10
R42 /vout- VEE 4k
R29 /vout+ VEE 4k
R43 VCC /differentialAmplifierBuffer/vcb 10k
R44 /differentialAmplifierBuffer/vcb VEE 18k
C12 /differentialAmplifierBuffer/vcb 0 C
.control
tran 1ns 500ns
tran 1ns 500ns
write
write
.endc
.end
